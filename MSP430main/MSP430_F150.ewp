# IAR project MSP430_F150.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xllff.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: DEBUG; RAM_VECTOR
  ICC430.newCCIncludePaths: $PROJ_DIR$; Drivers\inc; Drivers\src; HardWare; HardWare\delay; HardWare\nrf24l01; System; System\inc; System\src; User; User\USER; HardWare; $PROJ_DIR$; MATH; HAL; src; Communication; Control; DataBase; GCS; MidWare; driverlib; driverlib\inc
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 2
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5529.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xllfn.h
  ICC430.CCDefines: NDEBUG; RAM_VECTOR
  ICC430.newCCIncludePaths: $PROJ_DIR$; Drivers\inc; Drivers\src; Drivers\src\USB; Drivers\src\USB\USB_config; Drivers\src\USB\USB_User; Drivers\srcUSB\USB_API\USB_CDC_API; Drivers\src\USB\USB_API\USB_HID_API; Drivers\src\USB\USB_API\USB_MSC_API; HardWare\KEY; HardWare\LED; HardWare\12864; HardWare\oled; HardWare\mpu6050\inc; HardWare\mpu6050\src; HardWare\nokia5110\inc; HardWare\nokia5110\src; HardWare\LQ_1.8_TFT; HardWare\LCD_API; HardWare\2.2TFT; HardWare\delay; System; System\inc; System\src; User; User\USER; Lib\UCOSII\CONFIG; Lib\uCOSII\App; Lib\uCOSII\CONFIHG; Lib\uCOSII\PORT; Lib\UCOSII\CORE; Lib\FatFs; Lib\FatFs\option; src; HardWare; HardWare\nrf24l01; MATH
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group Communication
    Communication/: communication.c communication.h ZKHD_Link.c ZKHD_Link.h
  group Control
    Control/: control.c control.h height_control.c height_control.h Init.c kernel.c remote.c remote.h speed_estimator.c speed_estimator.h
  group DataBase
    DataBase/: fmuConfig.h include.h queue.c queue.h
  group driverlib
    driverlib/: adc10_a.c adc10_a.h adc12_a.c adc12_a.h aes.c aes.h battbak.c battbak.h comp_b.c comp_b.h crc.c crc.h ctsd16.c ctsd16.h dac12_a.c dac12_a.h dma.c dma.h driverlib.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h flashctl.c flashctl.h gpio.c gpio.h lcd_b.c lcd_b.h lcd_c.c lcd_c.h ldopwr.c ldopwr.h mpy32.c mpy32.h oa.c oa.h pmap.c pmap.h pmm.c pmm.h ram.c ram.h ref.c ref.h rtc_a.c rtc_a.h rtc_b.c rtc_b.h rtc_c.c rtc_c.h sd24_b.c sd24_b.h sfr.c sfr.h sysctl.c sysctl.h tec.c tec.h timer_a.c timer_a.h timer_b.c timer_b.h timer_d.c timer_d.h tlv.c tlv.h ucs.c ucs.h usci_a_spi.c usci_a_spi.h usci_a_uart.c usci_a_uart.h usci_b_i2c.c usci_b_i2c.h usci_b_spi.c usci_b_spi.h wdt_a.c wdt_a.h
  group driverlib/inc
    driverlib/inc/: hw_memmap.h version.h
  group GCS
    GCS/: gcs.c gcs.h
  group HardWare
    HardWare/: LED.c LED.h motor.c motor.h mpu6050.c mpu6050.h nrf24l01.c nrf24l01.h SPL06.c spl06.h
  group MATH
    MATH/: filter.c filter.h imu.c imu.h kalman.c kalman.h myMath.c myMath.h pid.c pid.h
  group MidWare
    MidWare/: board.c board.h delay.c delay.h flash.c flash.h i2c.c i2c.h spi.c spi.h timer.c timer.h UART.c UART.h
  group User
    User/: main.c
